Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-04-10T22:41:24
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Apr 10 22:41:24 2020 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{B0BF3029-82E2-44B2-BE77-52EA33B3E5B9}\ifc * Database version: 5507 * Database creation date: Fri Apr 10 22:41:24 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Apr 10 22:41:24 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Apr 10 22:41:24 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 6567Z Urinal flusher, 6 V, Bluetooth, 6567Z(2020):6567Z Urinal flusher, 6 V, Bluetooth:354404
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - NominalDepth: 95 mm; NominalHeight: 260 mm; NominalWidth: 65.0369 mm; Projection: 81 mm
Type - Electrical(Type) - Battery: Lithium 2CR5 6 V; Bluetooth: 4.x; Operating Voltage: 6 V; Protection Class: IP 55
Type - General(Type) - Author: Convergo AB; BIMObjectName: 6567Z(2020); ConvergoRefNr: 0087-2003-0058-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Urinal flushing valves; NBSReference: 45-35-70/355; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_35_93_80; Uniclass2015Description: Urinal flushing valves; Uniclass2015Reference: Pr_40_20_93_79; Version: 1; VersionDate: 06/04/2020
Type - Green Building Properties(Type) - Backflow Prevention EN1717: EB; Customs Code: 84818011; EAN Number: 6414150095733; EMC Directive: 2014/30/EU; EN Standard: EN 15091; LVI Number: 6416107; NRF Number: 4203714; RSKNumber: 8057131; VVS Number: 618852144
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/6567Z; Catalog Drawing URL: http://static.oras.com/catdrw/6567Z; Class: Touchless;Bluetooth®;Battery-operated; Dimension Drawing URL: http://static.oras.com/dimdrw/6567Z; FDV Document URL: http://www.oras.com/datasheet/6567Z/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/6567Z; Group: Urinals; Manufacturer: Oras; Market: INT;DNK;EST;FIN;LVA;LTU;NOR;POL;RUS;SWE;UKR; Model: 6567Z Urinal flusher, 6 V, Bluetooth; Name_en: 6567Z Urinal flusher, 6 V, Bluetooth; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 210 x 165 x 60 mm; Package Weight: 1.394 kg; Product Code: 6567Z; Product Datasheet: http://www.oras.com/datasheet/6567Z/en; Product Family: Oras Electra; Product Image URL: http://static.oras.com/image/6567Z; Product URL: http://static.oras.com/6567Z; Type Name: 6567Z Urinal flusher, 6 V, Bluetooth
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: Adjustable settings (via bluetooth); Afterflush Period: 6 s (1-20 s); Automatic Flush: 24 h (off/1-120 h); AutomaticFlushPeriod: 6; Connection: With shutoff valves; Connection Size: G1/2; Electronic Parts: Autofocus sensor;Solenoid valve;Low battery indication; Flow Rate At 300kPa: 0.0197762 m3/s; Installation and Maintenance: http://static.oras.com/manual/6567Z; Installation Type: Wall-mounted; Max. Hot Water Supply: 70 kg/K/s3; Mechanical Parts: Litter filter(s); Pre-flush Period: 2 s (OFF / 1-10 s); Pressure Loss With Flow 02ls: 40000 Pa; Spare Parts: http://static.oras.com/sp/6567Z
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 6567Z(2020); Features: Touchless;Bluetooth®;Battery-operated; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 6567Z; Name: 6567Z Urinal flusher, 6 V, Bluetooth; ReplacementCost: n/a; Shape: Sculptured; Size: 65x95x260 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 6567Z; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 6567Z Urinal flusher, 6 V, Bluetooth
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0488972 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 15 mm; InletDistance: 160 mm; OutletAngle: 0 deg; Volume: 0.00161631 m3
Identity Data - Mark: 16
Mechanical - System Classification: Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 6567Z(2020): 6567Z Urinal flusher, 6 V, Bluetooth; Family and Type: 6567Z(2020): 6567Z Urinal flusher, 6 V, Bluetooth; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 6567Z(2020): 6567Z Urinal flusher, 6 V, Bluetooth; Type Id: 6567Z(2020): 6567Z Urinal flusher, 6 V, Bluetooth; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
